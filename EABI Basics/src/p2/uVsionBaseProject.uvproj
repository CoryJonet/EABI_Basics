# Keil uVision project uVsionBaseProject.uvproj, settings and files
target base (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: uVsionBaseProject
  c flags: Optim=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ece353.sct
  link misc: --entry Reset_Handler
  group src
    ./: main.s Startup.s blockSwap.s
